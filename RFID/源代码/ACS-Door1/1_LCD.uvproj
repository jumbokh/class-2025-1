# Keil uVision project 1_LCD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: 1_LCD +hex
  c flags: Optim=1
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Lpc1xxx
    ./lpc1xxx/: startup_LPC11xx.s system_LPC11xx.c
  group CM0
    ./CM0/: core_cm0.c
  group core
    ./core/: beep.c delay.c gpio.c lcd.c led.c relay.c rfid125K.c sys_init.c
  group User
    ./User Code/: main.c
